# Keil uVision project DS18B20.uvproj, settings and files
target IK-STC15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source;..\User
  group USER
    ../User/: main.c
  group SOURCE
    ../Source/: delay.c uart.c timeControl.c ds18b20.c oled.c oledfont.c led.c
    ./: i2c.c
  group DOC
    ../Doc/: ReadMe.txt
